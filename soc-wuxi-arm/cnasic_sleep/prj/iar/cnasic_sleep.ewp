# IAR project cnasic_sleep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\App\inc; ..\..\Chip\Startup\inc; ..\..\Chip\Hal_lib\inc; ..\..\Chip\CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: cnasic_sleep.out
  ILINK.IlinkIcfFile: cnasic_soc_blue_128kRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../../App/: delay.c main.c
  group Hal_lib
    ../../Chip/Hal_lib/: gpio.c mem.c nvic.c timer.c usart.c
  group Startup
    ../../Chip/Startup/: cnasic_soc_bule.s
