<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\cnasic_sleep.ewp</path>
    </project>
    <batchBuild />
</workspace>
