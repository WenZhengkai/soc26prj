# Keil uVision project cnasic_sleep.uvprojx, settings and files
target cnasic_sleep (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: CMSDK_CM3 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.7.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cnasic_sleep +hex
  AfterMake: fromelf.exe --vhx --32x1 --output=.\output\outfile.bin .\objects\cnasic_sleep.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\App\inc;..\..\Chip\CMSIS;..\..\Chip\Hal_lib\inc;..\..\Chip\Startup\inc
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x8000 size 0xa000
  link misc: --entry Reset_Handler
  group App
    ../../App/: delay.c main.c
  group Hal_lib
    ../../Chip/Hal_lib/: gpio.c mem.c nvic.c timer.c usart.c
  group Startup
    ../../Chip/Startup/keil/: cnasic_soc.s
